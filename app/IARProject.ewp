# IAR project IARProject.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xldn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ; source; ..\os\EvalBoards\TI\MSP-EXP430F5438\IAR\uCOS-II; ..\os\EvalBoards\TI\MSP-EXP430F5438\IAR\BSP; ..\os\EvalBoards\TI\MSP-EXP430F5438\IAR\BSP\MSP-EXP430F5438 HAL\; ..\os\EvalBoards\TI\MSP-EXP430F5438\IAR\BSP\F5xx_F6xx_Core_lib\; ..\os\uC-CPU\; ..\os\uC-CPU\MSP430X\IAR; ..\os\uC-LIB\; ..\os\uCOS-II\Source\; ..\os\uCOS-II\Ports\MSP430X\IAR\MSP430x5xx\
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.ADefines: DISABLE_WATCHDOG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group App
    source/: app.c app_config.h includes.h
  group App/Shared
    source/shared/: state_manager.c state_manager.h synchronization.c synchronization.h task_helpers.c task_helpers.h types.h
  group App/Tasks
    source/tasks/: buttons_task.c buttons_task.h lcd_task.c lcd_task.h main_task.c main_task.h record_task.c record_task.h rx_task.c rx_task.h tx_task.c tx_task.h
  group BSP
    ../os/EvalBoards/TI/MSP-EXP430F5438/IAR/BSP/: bsp.c bsp.h
  group BSP/F5xx_F6xx_Core_Lib
    ../os/EvalBoards/TI/MSP-EXP430F5438/IAR/BSP/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_TLV.c HAL_UCS.c
    ../os/EvalBoards/TI/MSP-EXP430F5438/IAR/BSP/F5xx_F6xx_Core_lib/: hal_flash.h HAL_MACROS.h HAL_PMM.h HAL_TLV.h HAL_UCS.h
  group BSP/MSP-EXP430F5438 HAL
    ../os/EvalBoards/TI/MSP-EXP430F5438/IAR/BSP/MSP-EXP430F5438 HAL/: cc2500.h hal_adc.h hal_board.c hal_board.h hal_buttons.c hal_buttons.h hal_lcd.c hal_lcd.h hal_lcd_fonts.h hal_MSP-EXP430F5438.h hal_rf.c hal_rf.h
  group Lib
    ../os/EvalBoards/TI/MSP-EXP430F5438/IAR/uCOS-II/: app_hooks.c cpu_cfg.h cstartup.s43 os_cfg.h
  group uC/CPU
    ../os/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/MSP430X
    ../os/uC-CPU/msp430x/IAR/: cpu.h
  group uC/LIB
    ../os/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-II/Port
    ../os/uCOS-II/Ports/MSP430X/IAR/MSP430x5xx/: os_cpu.h os_cpu_a.s43 os_cpu_c.c os_dbg.c
  group uC/OS-II/Source
    ../os/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
